# Keil uVision project i2s.uvprojx, settings and files
target i2s (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: i2s
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_PRESENT=1
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Drivers\BSP\STM32F4-Discovery;..\Drivers\BSP\Components\Common;..\Drivers\BSP\Components\lis3dsh;..\Drivers\BSP\Components\lis302dl;..\Drivers\Middlewares\ST\STM32_Audio\Addons\PDM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/BSP
    ../Drivers/BSP/Components/lis3dsh/: lis3dsh.c
    ../Drivers/BSP/Components/lis302dl/: lis302dl.c
    ../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_audio.c stm32f4_discovery_accelerometer.c
  group MiddleWares/PDM
    $TC_ROOT$/../../Users/tarka/Documents/rifat/i2s_999/i2s/Drivers/Middlewares/ST/STM32_Audio/Addons/PDM/: libPDMFilter_CM4_Keil.lib libPDMFilter_CM4F_Keil.lib
  group FFT_Libs
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/5.0.1/CMSIS/Lib/ARM/: arm_cortexM4l_math.lib arm_cortexM4lf_math.lib
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rng.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_spi.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c main.c
    ../Inc/: test_wave.h
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
